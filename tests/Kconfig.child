## tests/Kconfig.main
```kconfig
mainmenu MAIN
    config A
        prompt "config A"

	source "./Kconfig.child"

	config C
        prompt "config C"
```
